## drivers_templates/armadeus/Kconfig
```kconfig
#
config ARMADEUS_FPGA_SPISNIF
	tristate "FPGA SPISNIF"
	depends on POD_DRIVERS
	---help---
	  SPI snifer component
```
